## CMakeLists.txt
```
cmake_minimum_required(VERSION 3.20.0)
set (CMAKE_CXX_STANDARD 20)

find_package(Zephyr REQUIRED HINTS $ENV{ZEPHYR_BASE})

project(esp-zephyr)

# add_subdirectory(src)

set(APP_SOURCES
    src/main.cpp
    src/scanner.cpp
    src/oled.cpp
    src/soil_sensor.cpp
)

target_sources(app PRIVATE ${APP_SOURCES})
```

## prj.conf
```kconfig
CONFIG_THREAD_NAME=y
CONFIG_DEBUG_THREAD_INFO=n

CONFIG_NO_OPTIMIZATIONS=n
CONFIG_DEBUG_OPTIMIZATIONS=y

CONFIG_STD_CPP20=y
CONFIG_NEWLIB_LIBC=y

# Console
CONFIG_SERIAL=y
CONFIG_CONSOLE=y
CONFIG_UART_CONSOLE=y
CONFIG_PRINTK=y

# Networking
CONFIG_NETWORKING=y
CONFIG_NET_L2_ETHERNET=y
CONFIG_NET_L2_WIFI_MGMT=y
CONFIG_NET_MGMT=y
CONFIG_NET_MGMT_EVENT=y
CONFIG_NET_MGMT_EVENT_INFO=y

# Wi-Fi
CONFIG_WIFI=y
CONFIG_WIFI_ESP32=y

# Memory and stacks
CONFIG_HEAP_MEM_POOL_SIZE=98304
CONFIG_MAIN_STACK_SIZE=4096
CONFIG_SYSTEM_WORKQUEUE_STACK_SIZE=4096

CONFIG_NET_TX_STACK_SIZE=2048
CONFIG_NET_RX_STACK_SIZE=4096

CONFIG_NET_PKT_RX_COUNT=16
CONFIG_NET_PKT_TX_COUNT=16
CONFIG_NET_BUF_RX_COUNT=32
CONFIG_NET_BUF_TX_COUNT=32

# Logging
CONFIG_LOG=n
CONFIG_WIFI_LOG_LEVEL_INF=y

#Display
CONFIG_I2C=y
# CONFIG_DISPLAY=y
# CONFIG_SSD1306=y
# CONFIG_SSD1306_DEFAULT=y
# CONFIG_SSD1306_DEFAULT_CONTRAST=128

CONFIG_STATIC_INIT_GNU=y

#Downloader
CONFIG_BOOTLOADER_MCUBOOT=n

#AnDC
CONFIG_ADC=y
```

## boards/esp32s3_devkit/esp32s3_devkitc_esp32s3_procpu.overlay
```dts
// / {
//     chosen {
//         zephyr,display = &ssd1306;
//     };
// };

// & i2c0 {
//     status = "okay";

//     ssd1306: ssd1306@3c {
//         compatible = "solomon,ssd1306fb";
//         reg = <0x3c>;

//         width = <128>;
//         height = <32>;

//         segment-offset = <0>;
//         page-offset = <0>;
//         display-offset = <0>;
//         multiplex-ratio = <31>;

//         segment-remap;
//         com-invdir;
//         prechargep = <0x22>;
//     };
// };

/ {
    zephyr,user {
        io-channels = <&adc1 3>;
    };
};

&i2c0 {
    status = "okay";
    clock-frequency = <400000>;
};

&adc1{
    status = "okay";
};
```

## src/main.cpp
```c
#include "scanner.h"
#include "oled.h"
#include "soil_sensor.h"
#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/devicetree.h>
#include <zephyr/drivers/i2c.h>
#include <zephyr/sys/printk.h>

#define WIFI_STACK_SIZE 4096
#define OLED_STACK_SIZE 2048

#define WIFI_PRIORITY 5
#define OLED_PRIORITY 5

K_THREAD_STACK_DEFINE(wifi_stack, WIFI_STACK_SIZE);
K_THREAD_STACK_DEFINE(oled_stack, OLED_STACK_SIZE);
K_THREAD_STACK_DEFINE(soil_stack, OLED_STACK_SIZE);

static struct k_thread wifi_thread_data;
static struct k_thread oled_thread_data;
static struct k_thread soil_thread_data;

static const struct device *i2c = DEVICE_DT_GET(DT_NODELABEL(i2c0));
static SSD1306 oled(i2c, OLED_I2C_ADDR);
static WifiScanner scanner;
static SoilMoistureSensor sensor;

static void wifi_thread_entry(void *p1, void *p2, void *p3)
{
    auto *scanner = static_cast<WifiScanner *>(p1);

    printk("Wi-Fi thread started\n");

    int ret = scanner->start();
    printk("Wi-Fi scanner stopped: %d\n", ret);
}

static void oled_thread_entry(void *p1, void *p2, void *p3)
{
    auto *display = static_cast<SSD1306 *>(p1);
    auto *scanner = static_cast<WifiScanner *>(p2);
    auto *sensor = static_cast<SoilMoistureSensor *>(p3);
    char text[32];
    printk("OLED thread started\n");

    display->clear();
    display->drawString(0, 0, "ESP32-S3", true);
    display->drawString(0, 10, "Wi-Fi scanner", true);
    display->update();

    while (true)
    {
        int count = scanner->getNetworkCount();
        int soil_percent;
        sensor->readHumidityPercent(soil_percent);

        display->clear();
        display->drawString(0, 0, "Wi-Fi scan result:", true);

        snprintk(text, sizeof(text), "Found %d networks", count);
        display->drawString(0, 12, text, true);

        snprintk(text, sizeof(text), "Value of humidity %d", soil_percent);
        display->drawString(0, 24, text, true);

        display->update();

        k_sleep(K_SECONDS(1));
    }
}

static void soil_thread_entry(void *p1, void *p2, void *p3)
{
    auto *sensor = static_cast<SoilMoistureSensor *>(p1);

    while (true) {
        int16_t raw = 0;
        const int raw_ret = sensor->readRaw(raw);

        if (raw_ret < 0) 
        {
            printk("ERROR: ADC read failed: %d\n", raw_ret);
            k_sleep(K_SECONDS(2));
            continue;
        }

        int humidity = 0;
        const int humidity_ret = sensor->readHumidityPercent(humidity);

        if (humidity_ret < 0) {
            printk("ERROR: Humidity calculation failed: %d\n", humidity_ret);
            k_sleep(K_SECONDS(2));
            continue;
        }

        printk("ADC raw: %d | Soil moisture: %d%%\n", raw, humidity);

        k_sleep(K_SECONDS(2));
    }
}

int main()
{
    printk("Application startingssssss\n");

    if (!device_is_ready(i2c))
    {
        printk("ERROR: I2C device is not ready\n");
        return 0;
    }

    if (!oled.init())
    {
        printk("ERROR: OLED initialization failed\n");
        return 0;
    }

    if (!sensor.init())
    {
        printk("ERROR: ADC initialization failed\n");
        return 0;
    }

    k_thread_create( &wifi_thread_data, wifi_stack, K_THREAD_STACK_SIZEOF(wifi_stack), 
                    wifi_thread_entry, &scanner, nullptr, nullptr, WIFI_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&oled_thread_data, oled_stack, K_THREAD_STACK_SIZEOF(oled_stack),
                    oled_thread_entry, &oled, &scanner, &sensor, OLED_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&soil_thread_data, soil_stack, K_THREAD_STACK_SIZEOF(oled_stack),
                    soil_thread_entry, &sensor, nullptr, nullptr, OLED_PRIORITY, 0, K_NO_WAIT);

    while (true)
    {
        printk("All threads created\n");
        k_sleep(K_SECONDS(10));
    }
    
    return 0;
}
```

## src/oled.cpp
```c
#include "oled.h"
#include <cstring>

SSD1306::SSD1306(const struct device *i2c, uint8_t addr)
                                :  i2c_(i2c), addr_(addr) 
{
    memset(buffer_, 0, sizeof(buffer_));
}

int SSD1306::writeCmd(uint8_t cmd)
{
    uint8_t buf[2] = {0x00, cmd};  // 0x00 – управляющий байт: команда
    return i2c_write(i2c_, buf, sizeof(buf), addr_);
}

int SSD1306::writeData(const uint8_t *data, size_t len) 
{
    uint8_t buf[33];
    buf[0] = 0x40;  // Control byte: данные

    while (len > 0) {
        const size_t chunk_ = (len > 32) ? 32 : len;
        memcpy(&buf[1], data, chunk_);
        const int ret = i2c_write(i2c_, buf, chunk_ + 1, addr_);
        if (ret < 0)
            return ret;

        data += chunk_;
        len -= chunk_;
    }

    return 0;
}

bool SSD1306::init()
{
    if (i2c_ == nullptr || !device_is_ready(i2c_)) 
    {
        return false;
    }
    k_msleep(100);

    auto cmd = [this](uint8_t value) /* Что это? */
    {
        return writeCmd(value) == 0;
    };

    if (!cmd(SSD1306_SET_DISP_OFF))           return false;

    if (!cmd(SSD1306_SET_DISP_CLK_DIV))       return false;
    if (!cmd(0x80))                           return false;

    if (!cmd(SSD1306_SET_MUX_RATIO))          return false;
    if (!cmd(OLED_HEIGHT - 1))                return false;

    if (!cmd(SSD1306_SET_DISP_OFFSET))        return false;
    if (!cmd(0x00))                           return false;

    if (!cmd(SSD1306_SET_DISP_START_LINE))    return false;

    if (!cmd(SSD1306_SET_CHARGE_PUMP))        return false;
    if (!cmd(0x14))                           return false;

    if (!cmd(SSD1306_SET_MEM_MODE))           return false;
    if (!cmd(0x00))                           return false;

    if (!cmd(SSD1306_SET_SEG_REMAP | 0x01))   return false;
    if (!cmd(SSD1306_SET_COM_OUT_DIR | 0x08)) return false;

    if (!cmd(SSD1306_SET_COM_PIN_CFG))        return false;
    if (!cmd(0x02))                           return false;

    if (!cmd(SSD1306_SET_CONTRAST))           return false;
    if (!cmd(0x7F))                           return false;

    if (!cmd(SSD1306_SET_ENTIRE_ON))          return false;
    if (!cmd(SSD1306_SET_NORM_DISP))          return false;

    clear();

    if (!update()) 
    {
        return false;
    }

    if (!cmd(SSD1306_SET_DISP_ON)) 
    {
        return false;
    }

    return true;
}

void SSD1306::clear()
{
    memset(buffer_, 0, sizeof(buffer_));
}

bool SSD1306::update()
{
    if (writeCmd(SSD1306_SET_COL_ADDR) < 0) 
    {
        return false;
    }

    if (writeCmd(0) < 0) 
    {
        return false;
    }

    if (writeCmd(OLED_WIDTH - 1) < 0) 
    {
        return false;
    }

    if (writeCmd(SSD1306_SET_PAGE_ADDR) < 0) 
    {
        return false;
    }

    if (writeCmd(0) < 0) 
    {
        return false;
    }

    if (writeCmd((OLED_HEIGHT / 8) - 1) < 0) 
    {
        return false;
    }

    return writeData(buffer_, sizeof(buffer_)) == 0;
}

// ----- Draw pixel -----
void SSD1306::drawPixel(int16_t x, int16_t y, bool color)
{
    if (x < 0 || x >= OLED_WIDTH || y < 0 || y >= OLED_HEIGHT) return;
    uint16_t idx = x + (y / 8) * OLED_WIDTH;
    uint8_t bit = 1 << (y % 8);
    if (color) buffer_[idx] |= bit;
    else       buffer_[idx] &= ~bit;
}

// ----- Шрифт 5x7 (символы ASCII 32..127) -----
// Каждый символ – 5 байт (по 5 столбцов), биты строки 0..6 (7 строк)
static const uint8_t font5x7[][5] = 
{
    {0x00, 0x00, 0x00, 0x00, 0x00}, // 32 space
    {0x00, 0x00, 0x5F, 0x00, 0x00}, // 33 !
    {0x00, 0x07, 0x00, 0x07, 0x00}, // 34 "
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, // 35 #
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, // 36 $
    {0x23, 0x13, 0x08, 0x64, 0x62}, // 37 %
    {0x36, 0x49, 0x55, 0x22, 0x50}, // 38 &
    {0x00, 0x05, 0x03, 0x00, 0x00}, // 39 '
    {0x00, 0x1C, 0x22, 0x41, 0x00}, // 40 (
    {0x00, 0x41, 0x22, 0x1C, 0x00}, // 41 )
    {0x08, 0x2A, 0x1C, 0x2A, 0x08}, // 42 *
    {0x08, 0x08, 0x3E, 0x08, 0x08}, // 43 +
    {0x00, 0x50, 0x30, 0x00, 0x00}, // 44 ,
    {0x08, 0x08, 0x08, 0x08, 0x08}, // 45 -
    {0x00, 0x60, 0x60, 0x00, 0x00}, // 46 .
    {0x20, 0x10, 0x08, 0x04, 0x02}, // 47 /
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, // 48 0
    {0x00, 0x42, 0x7F, 0x40, 0x00}, // 49 1
    {0x42, 0x61, 0x51, 0x49, 0x46}, // 50 2
    {0x21, 0x41, 0x45, 0x4B, 0x31}, // 51 3
    {0x18, 0x14, 0x12, 0x7F, 0x10}, // 52 4
    {0x27, 0x45, 0x45, 0x45, 0x39}, // 53 5
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, // 54 6
    {0x01, 0x71, 0x09, 0x05, 0x03}, // 55 7
    {0x36, 0x49, 0x49, 0x49, 0x36}, // 56 8
    {0x06, 0x49, 0x49, 0x29, 0x1E}, // 57 9
    {0x00, 0x36, 0x36, 0x00, 0x00}, // 58 :
    {0x00, 0x56, 0x36, 0x00, 0x00}, // 59 ;
    {0x08, 0x14, 0x22, 0x41, 0x00}, // 60 <
    {0x14, 0x14, 0x14, 0x14, 0x14}, // 61 =
    {0x00, 0x41, 0x22, 0x14, 0x08}, // 62 >
    {0x02, 0x01, 0x51, 0x09, 0x06}, // 63 ?
    {0x32, 0x49, 0x79, 0x41, 0x3E}, // 64 @
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, // 65 A
    {0x7F, 0x49, 0x49, 0x49, 0x36}, // 66 B
    {0x3E, 0x41, 0x41, 0x41, 0x22}, // 67 C
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, // 68 D
    {0x7F, 0x49, 0x49, 0x49, 0x41}, // 69 E
    {0x7F, 0x09, 0x09, 0x09, 0x01}, // 70 F
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, // 71 G
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, // 72 H
    {0x00, 0x41, 0x7F, 0x41, 0x00}, // 73 I
    {0x20, 0x40, 0x41, 0x3F, 0x01}, // 74 J
    {0x7F, 0x08, 0x14, 0x22, 0x41}, // 75 K
    {0x7F, 0x40, 0x40, 0x40, 0x40}, // 76 L
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, // 77 M
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, // 78 N
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, // 79 O
    {0x7F, 0x09, 0x09, 0x09, 0x06}, // 80 P
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, // 81 Q
    {0x7F, 0x09, 0x19, 0x29, 0x46}, // 82 R
    {0x46, 0x49, 0x49, 0x49, 0x31}, // 83 S
    {0x01, 0x01, 0x7F, 0x01, 0x01}, // 84 T
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, // 85 U
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, // 86 V
    {0x7F, 0x20, 0x18, 0x20, 0x7F}, // 87 W
    {0x63, 0x14, 0x08, 0x14, 0x63}, // 88 X
    {0x07, 0x08, 0x70, 0x08, 0x07}, // 89 Y
    {0x61, 0x51, 0x49, 0x45, 0x43}, // 90 Z
    {0x00, 0x7F, 0x41, 0x41, 0x00}, // 91 [
    {0x02, 0x04, 0x08, 0x10, 0x20}, // 92 backslash
    {0x00, 0x41, 0x41, 0x7F, 0x00}, // 93 ]
    {0x04, 0x02, 0x01, 0x02, 0x04}, // 94 ^
    {0x40, 0x40, 0x40, 0x40, 0x40}, // 95 _
    {0x00, 0x01, 0x02, 0x04, 0x00}, // 96 `
    {0x20, 0x54, 0x54, 0x54, 0x78}, // 97 a
    {0x7F, 0x48, 0x44, 0x44, 0x38}, // 98 b
    {0x38, 0x44, 0x44, 0x44, 0x20}, // 99 c
    {0x38, 0x44, 0x44, 0x48, 0x7F}, // 100 d
    {0x38, 0x54, 0x54, 0x54, 0x18}, // 101 e
    {0x08, 0x7E, 0x09, 0x01, 0x02}, // 102 f
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, // 103 g
    {0x7F, 0x08, 0x04, 0x04, 0x78}, // 104 h
    {0x00, 0x44, 0x7D, 0x40, 0x00}, // 105 i
    {0x20, 0x40, 0x44, 0x3D, 0x00}, // 106 j
    {0x7F, 0x10, 0x28, 0x44, 0x00}, // 107 k
    {0x00, 0x41, 0x7F, 0x40, 0x00}, // 108 l
    {0x7C, 0x04, 0x18, 0x04, 0x78}, // 109 m
    {0x7C, 0x08, 0x04, 0x04, 0x78}, // 110 n
    {0x38, 0x44, 0x44, 0x44, 0x38}, // 111 o
    {0x7C, 0x14, 0x14, 0x14, 0x08}, // 112 p
    {0x08, 0x14, 0x14, 0x18, 0x7C}, // 113 q
    {0x7C, 0x08, 0x04, 0x04, 0x08}, // 114 r
    {0x48, 0x54, 0x54, 0x54, 0x20}, // 115 s
    {0x04, 0x3F, 0x44, 0x40, 0x20}, // 116 t
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, // 117 u
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, // 118 v
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, // 119 w
    {0x44, 0x28, 0x10, 0x28, 0x44}, // 120 x
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, // 121 y
    {0x44, 0x64, 0x54, 0x4C, 0x44}, // 122 z
    {0x00, 0x08, 0x36, 0x41, 0x00}, // 123 {
    {0x00, 0x00, 0x7F, 0x00, 0x00}, // 124 |
    {0x00, 0x41, 0x36, 0x08, 0x00}, // 125 }
    {0x08, 0x08, 0x2A, 0x1C, 0x08}, // 126 ~
    {0x00, 0x00, 0x00, 0x00, 0x00}  // 127 DEL (пусто)
};

void SSD1306::drawChar(int16_t x, int16_t y, char c, bool color) 
{
    if (c < 32 || c > 127) c = 32;
    uint8_t idx = c - 32;
    for (int col = 0; col < 5; col++) 
    {
        uint8_t line = font5x7[idx][col];
        for (int row = 0; row < 7; row++) 
        {
            if (line & (1 << row)) 
            {
                drawPixel(x + col, y + row, color);
            }
        }
    }
}

void SSD1306::drawString(int16_t x, int16_t y, const char *str, bool color) 
{
    while (*str) 
    {
        drawChar(x, y, *str++, color);
        x += 6; // 5 пикселей ширина + 1 пробел
        if (x + 5 >= OLED_WIDTH) // перенос строки
        { 
            x = 0;
            y += 8;
        }
    }
}
```

## src/oled.h
```c
#include <cstdint>
#include <zephyr/device.h>
#include <zephyr/drivers/display.h>
#include <zephyr/drivers/i2c.h>

#define OLED_WIDTH          128
#define OLED_HEIGHT         32
#define OLED_BUFFER_SIZE    (OLED_WIDTH * OLED_HEIGHT / 8) // 512 byts
#define OLED_I2C_ADDR       0x3C

// ----- Команды SSD1306 (из даташита) -----
#define SSD1306_SET_MEM_MODE        0x20
#define SSD1306_SET_COL_ADDR        0x21
#define SSD1306_SET_PAGE_ADDR       0x22
#define SSD1306_SET_DISP_START_LINE 0x40
#define SSD1306_SET_CONTRAST        0x81
#define SSD1306_SET_CHARGE_PUMP     0x8D
#define SSD1306_SET_SEG_REMAP       0xA0
#define SSD1306_SET_ENTIRE_ON       0xA4
#define SSD1306_SET_NORM_DISP       0xA6
#define SSD1306_SET_MUX_RATIO       0xA8
#define SSD1306_SET_DISP_OFF        0xAE
#define SSD1306_SET_DISP_ON         0xAF
#define SSD1306_SET_COM_OUT_DIR     0xC0
#define SSD1306_SET_DISP_OFFSET     0xD3
#define SSD1306_SET_DISP_CLK_DIV    0xD5
#define SSD1306_SET_PRECHARGE       0xD9
#define SSD1306_SET_COM_PIN_CFG     0xDA
#define SSD1306_SET_VCOM_DET        0xDB

class SSD1306 
{
public:
    explicit SSD1306(const struct device *i2c, uint8_t addr = OLED_I2C_ADDR);

    bool init();
    void clear();
    bool update();

    void drawPixel(int16_t x, int16_t y, bool color);
    void drawChar(int16_t x, int16_t y, char c, bool color);
    void drawString(int16_t x, int16_t y, const char *str, bool color);

private:
    const struct device *i2c_;
    uint8_t addr_;
    uint8_t buffer_[OLED_BUFFER_SIZE];

    int writeCmd(uint8_t cmd);
    int writeData(const uint8_t *data, size_t len);
};
```

## src/scanner.cpp
```c
#include "scanner.h"

#include <zephyr/kernel.h>
#include <zephyr/net/net_if.h>
#include <zephyr/net/net_mgmt.h>
#include <zephyr/net/wifi_mgmt.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>

#include <errno.h>

K_SEM_DEFINE(scan_done, 0, 1);

WifiScanner::WifiScanner()
        : network_count(0)
{
    k_mutex_init(&count_mutex);
}

void WifiScanner::wifi_event_handler(struct net_mgmt_event_callback *cb, uint64_t mgmt_event, struct net_if *iface)
{
    ARG_UNUSED(iface);

    auto *scanner = CONTAINER_OF(cb, WifiScanner, wifi_cb);

    switch (mgmt_event)
    {
    case NET_EVENT_WIFI_SCAN_RESULT:
    {
        const auto *result = static_cast<const wifi_scan_result *>(cb->info);
        if (result == nullptr)
        {
            break;
        }

        k_mutex_lock(&scanner->count_mutex, K_FOREVER);
        scanner->network_count++;
        k_mutex_unlock(&scanner->count_mutex);

        printk("SSID: %.*s | RSSI: %d dBm | Channel: %u | Security: %d\n", result->ssid_length, reinterpret_cast<const char *>(result->ssid),
               result->rssi, result->channel, static_cast<int>(result->security));

        break;
    }

    case NET_EVENT_WIFI_SCAN_DONE:
        printk("Wi-Fi scan completed\n");
        k_sem_give(&scan_done);
        break;

    default:
        break;
    }
}

int WifiScanner::start()
{
    struct net_if *iface = net_if_get_default();

    if (iface == nullptr)
    {
        printk("ERROR: No network interface found\n");
        return -ENODEV;
    }

    net_mgmt_init_event_callback(&wifi_cb, wifi_event_handler, NET_EVENT_WIFI_SCAN_RESULT | NET_EVENT_WIFI_SCAN_DONE);
    net_mgmt_add_event_callback(&wifi_cb);

    int ret = net_if_up(iface);
    if (ret != 0 && ret != -EALREADY)
    {
        printk("ERROR: net_if_up failed: %d\n", ret);
        return ret;
    }

    printk("ESP32-S3 Wi-Fi scanner started\n");

    while (true)
    {
        k_mutex_lock(&count_mutex, K_FOREVER);
        network_count = 0;
        k_mutex_unlock(&count_mutex);
        printk("\nScanning Wi-Fi networks...\n");

        ret = net_mgmt(NET_REQUEST_WIFI_SCAN, iface, nullptr, 0);
        if (ret != 0)
        {
            printk("ERROR: Wi-Fi scan request failed: %d\n", ret);
        }
        else
        {
            ret = k_sem_take(&scan_done, K_SECONDS(30));

            if (ret != 0)
            {
                printk("WARNING: Wi-Fi scan timed out\n");
            }
            else
            {
                printk("Found %d networks\n", getNetworkCount());
            }
        }

        k_sleep(K_SECONDS(10));
    }

    return 0;
}

int WifiScanner::getNetworkCount()
{
    k_mutex_lock(&count_mutex, K_FOREVER);
    int count = network_count;
    k_mutex_unlock(&count_mutex);

    return count;
}
```

## src/scanner.h
```c
#pragma once

#include <cstdint>
#include <zephyr/kernel.h>
#include <zephyr/net/net_if.h>
#include <zephyr/net/net_mgmt.h>

class WifiScanner
{
public:
    WifiScanner();

    int start();
    int getNetworkCount();

private:
    static void wifi_event_handler(struct net_mgmt_event_callback *cb, uint64_t mgmt_event, struct net_if *iface);

    int network_count;
    struct k_mutex count_mutex;
    struct net_mgmt_event_callback wifi_cb;
};
```

## src/soil_sensor.cpp
```c
#include "soil_sensor.h"

#include <zephyr/devicetree.h>
#include <zephyr/kernel.h>
#include <zephyr/sys/util.h>

#include <cerrno>
#include <cstdint>

static const struct adc_dt_spec ADC_SPEC = ADC_DT_SPEC_GET_BY_IDX(DT_PATH(zephyr_user), 0);

SoilMoistureSensor::SoilMoistureSensor(){}

int SoilMoistureSensor::init()
{
    if (!adc_is_ready_dt(&ADC_SPEC)) {
        return -ENODEV;
    }

    const int ret = adc_channel_setup_dt(&ADC_SPEC);
    if (ret < 0) 
    {
        return ret;
    }

    sequence = {};

    const int seq_ret = adc_sequence_init_dt(&ADC_SPEC, &sequence);
    if (seq_ret < 0) 
    {
        return seq_ret;
    }

    sequence.buffer = sample_buffer;
    sequence.buffer_size = sizeof(sample_buffer);
    sequence.resolution = 12;
    sequence.oversampling = 0;

    return 0;
}

int SoilMoistureSensor::readRaw(int16_t& raw)
{
    int32_t sum = 0;

    for (int i = 0; i < SAMPLE_COUNT; ++i) 
    {    
        sample_buffer[0] = 0;

        sequence.buffer = sample_buffer;
        sequence.buffer_size = sizeof(sample_buffer);
        sequence.resolution = 12;
        sequence.channels = BIT(ADC_SPEC.channel_id);
        
        const int ret = adc_read(ADC_SPEC.dev, &sequence);
        if (ret < 0) 
        {
            return ret;
        }

        sum += sample_buffer[0];
        k_sleep(K_MSEC(2));
    }
    
    raw = static_cast<int16_t>(sum / SAMPLE_COUNT);
    
    return 0;
}

int SoilMoistureSensor::readHumidityPercent(int& percent)
{
    int16_t raw = 0;

    const int ret = readRaw(raw);
    if (ret < 0) 
    {
        return ret;
    }

    const int32_t range = static_cast<int32_t>(wet_raw_) - dry_raw_;
    if (range == 0) 
    {
        return -EINVAL;
    }

    int32_t value = (static_cast<int32_t>(raw) - dry_raw_) * 100 / range;

    if (value < 0) 
    {
        value = 0;
    }

    if (value > 100) 
    {
        value = 100;
    }

    percent = static_cast<int>(value);

    return 0;
}

void SoilMoistureSensor::setCalibration(int16_t dry, int16_t wet)
{
    dry_raw_ = dry;
    wet_raw_ = wet;
}
```

## src/soil_sensor.h
```c
#pragma once

#include <cstdint>

#include <zephyr/drivers/adc.h>

#define SAMPLE_COUNT    16

class SoilMoistureSensor {
public:
    SoilMoistureSensor();

    int init();
    int readRaw(int16_t& raw);
    int readHumidityPercent(int& percent);
    void setCalibration(int16_t dry, int16_t wet);

private:
    adc_sequence sequence{};

    int16_t sample_buffer[1]{};
    int16_t dry_raw_ = 4100;
    int16_t wet_raw_ = 1500;

};
```
